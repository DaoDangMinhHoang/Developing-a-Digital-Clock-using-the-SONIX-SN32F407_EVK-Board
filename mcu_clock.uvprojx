# Keil uVision project mcu_clock.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mcu_clock
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\User\Driver;.\User\Module
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c
  group Driver
    ./User/Driver/: ADC.c CMP.c CRC.c CT16B0.c CT16B1.c CT16B5.c DMA.c Flash.c GPIO.c OPA.c PFPA.c RTC.c SPI0.c SYS_con_drive.c SysTick.c UART0.c UART1.c Utility.c WDT.c ADC.h CMP.h CRC.h CT16.h CT16B0.h CT16B1.h CT16B5.h DMA.h Flash.h GPIO.h OPA.h RTC.h SPI.h SYS_con_drive.h SysTick.h UART.h Utility.h WDT.h
  group Module
    ./User/Module/: Segment.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
